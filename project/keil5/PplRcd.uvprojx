# Keil uVision project PplRcd.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PplRcd
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL,HSE_VALUE=8000000,_MCU_ENDIAN=1
  c misc: --diag_suppress=1295;--diag_suppress=1;--diag_suppress=177-D
  c include: ..\..\configs;..\..\BSP;..\..\sdhLib\inc;..\..\device\dev_LCD\nokia_5110;..\..\..\PplRcd;..\..\drive;..\..\device;..\..\Glyph;..\..\Expression;..\..\Views;..\..\REEC;..\..\model;..\..\sheet;..\..\usb;..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../../APP/: app_conf.h main.c osObjects.h sdhlibConf.h system.c system.h TDD.h Cmd_Thread.c sys_cmd.h Modbus_app.c Modbus_app.h channel_accumulated.c channel_accumulated.h
    ./: tdd.c
  group config
    ../../configs/: hardwareConfig.c hardwareConfig.h model_conf.h cfg_test.h
  group BSP
    ../../BSP/: intrInit.c mySystemClock.c pinmux.c power.c power.h
  group myLib
    ../../sdhLib/src/basis/: marco.c assert.c except.c
    ../../sdhLib/src/mem/: mem.c Ping_PongBuf.c
    ../../sdhLib/src/arithmetic/: cycQueue.c list.c bit.c crc.c
    ../../sdhLib/src/Communication/: smart_bus.c modbusRTU_cli.c
    ../../sdhLib/src/os/RTX/: rtx_depend.c
  group drive
    ../../drive/GPIO/: drive_gpio.c
    ../../drive/IIC/: drive_IIC.c
    ../../drive/SPI/: drive_spi.c
    ../../drive/uart/: drive_uart.c drive_uart.h
  group device
    ../../device/: device.c dev_lcd.c dev_cmd.h dev_lcd.h deviceId.h device.h dev_char.c
    ../../device/dev_uart/: dev_uart.c
    ../../device/dev_spi/: dev_spi.c
    ../../device/dev_LCD/UsartGpu/: dev_LcdUsartGpu.c dev_LcdUsartGpu.h
    ../../device/dev_IIC/: dev_IIC.c
    ../../device/dev_gpio/: device_gpio.c
  group Glyph
    ../../Glyph/: Gh_None.c glyph.c testGlyph.c Gh_txt.c Gh_Pic.c Gh_Rectangle.c
  group expression
    ../../Expression/: expression.c TxtExpr.c Reader.c ExpFactory.c NtButton.c NtInput.c GeometricsExpr.c PicExpr.c
  group utils
    ../../utils/: FM25.c hw_w25q.c keyboard.c rtc.c rtc_pcf8563.c Storage.c times.c Storage.h PHN_string.c PHN_string.h FM25.h log.c log.h time_func.c time_func.h
  group sheet
    ../../sheet/: sheet.c sheetMemento.c sheet.h sheetMemento.h
  group HMI
    ../../HMI/: chnInfoPic.c HMI.c Component_Button.c focus.c format.c HMIFactory.c HMI.h HMIFactory.h Component_Button.h Component_progress_bar.c Component_progress_bar.h HMI_striped_background.h HMI_striped_background.c HMI_curve.c HMI_curve.h Component_curve.h Component_curve.c Component_tips.c Component_tips.h HMI_Accumulate .c HMI_barGraph.c HMI_comm.c HMI_data.c HMI_keyboard.c HMI_main.c HMI_menu.c HMI_news_select.c HMI_setup.c HMI_windowns.c STG_ACC_day.c STG_ACC_month.c STG_news_alarm.c STG_news_power.c STG_set_accumulate.c STG_set_alarm.c STG_set_arithmetic.c STG_set_channel.c STG_set_dataBackUp.c STG_set_dataPrint.c STG_set_system.c STG_set_view.c HMI_main.h HMI_keyboard.h HMI_comm.h STG_Super_set.c
  group model
    ../../model/: Model.c Model_channel.c ModelFactory.c ModelTime.c Model.h Model_channel.h
  group control
    ../../Control/: Controller.c Controller.h CtlKey.c CtlKey.h CtlTimer.c CtlTimer.h
  group USB
    ../../USB/: Ch376.c Usb.c Ch376INC.h Usb.h Ch376.h usb_hardware_interface.c usb_hardware_interface.h
  group fs
    ../../fs/: easy_fs.c easy_fs.h
  group unit_test
    ../../unit_test/: test_w25q.c unit_test.c test_w25q.h unit_test.h test_efs.c test_efs.h
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
